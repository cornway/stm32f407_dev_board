# Keil uVision project main_server.uvprojx, settings and files
target app (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: main_server +hex
  AfterMake: C:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin Objects\main_server.axf --output img.bin
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c misc: --cpp11 --exceptions
  c include: ..\proc;..\misc\inc;..\misc\context\inc;..\misc\depend\Arm\CortexM4\inc
  memory RVCT4: ROM 0x2000000 size 0x8000
  memory RVCT9: RAM 0x20008000 size 0x8000
  memory RVCT10: RAM 0x10000000 size 0x1000
  group main
    ./: main.cpp
    ../misc/context/src/: vmapi.cpp
    ../misc/depend/Arm/CortexM4/src/: arm_api.s
software components: CMSIS:CORE 5.0.1, Device:Startup 2.6.0
