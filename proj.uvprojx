# Keil uVision project proj.uvprojx, settings and files
target stm32f417iet6 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F417IETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: proj +hex
  c flags: Optim=1 oTime=1 v6Lang=1 v6LangP=1 wLevel=2
  c misc: --cpp11 --exceptions
  c include: .\adv7180\inc;.\device\inc;.\drivers\inc;.\entry\inc;.\gui\inc;.\init\inc;.\it\inc;.\misc\inc;.\tft\inc;.\FatFs\src;.\FatFs\src\drivers;.\FatFs\src\option;.\STM32_USB_Device_Library\Class\MSC\Inc;.\STM32_USB_Device_Library\Core\Inc;.\pnesx\inc;.\misc\context\inc;.\misc\depend\Arm\CortexM4\inc;.\lwip-enc28j60-master\enc28j60driver;.\lwip-1.4.1\src\include;.\lwip-1.4.1\src\netif;.\lwip-1.4.1\src\api;.\lwip-1.4.1\src\core;.\lwip-1.4.1\src\include\ipv4;.\tcp_app\inc;.\analog\inc
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT6: RAM 0x60038400 size 0x7bff
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group entry
    ./entry/src/: main.cpp
  group device
    ./device/src/: device.cpp gpio.cpp time.cpp gui.cpp adv7180_interface.cpp tft_interface.cpp usbd_conf.c usbd_desc.c usbd_storage.c flash_disk_int.c flash_interface.cpp fgpu.c tsc2046.cpp tsc2046_interface.cpp sprite.cpp touch.cpp enc28j60_interface.cpp fpga.cpp fpgamch.cpp sensor_drv.cpp
    ./tft/src/: TFTili9486.cpp
    ./misc/src/: pp.cpp
    ./device/inc/: it_vect.h
  group drivers
    ./drivers/src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dcmi.c stm32f4xx_hal_dcmi_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_sram.c stm32f4xx_ll_fsmc.c stm32f4xx_hal_spi.c stm32f4xx_hal_hcd.c stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_ll_usb.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_dac.c stm32f4xx_hal_dac_ex.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c
  group it
    ./it/src/: stm32f4xx_it.cpp
  group init
    ./init/src/: init.cpp
  group misc
    ./misc/src/: dma_chain.cpp fft.cpp
  group usb
    ./STM32_USB_Device_Library/Class/MSC/Src/: usbd_msc.c usbd_msc_bot.c usbd_msc_data.c usbd_msc_scsi.c
    ./STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
  group fatfs
    ./FatFs/src/: diskio.c ff.c ff_gen_drv.c
    ./FatFs/src/option/: unicode.c syscall.c
    ./FatFs/src/drivers/: flash_diskio.c
  group pnesx
    ./pnesx/src/: K6502.cpp pNesX.cpp pNesX_Apu.cpp pNesX_Filer.cpp pNesX_Mapper.cpp pNesX_System_Targ.cpp
    ./entry/src/: pnesx_app.cpp
  group picture
    ./device/src/: bitmap.cpp icon.cpp gif.cpp
  group vm
    ./misc/context/src/: VM.cpp vmapi.cpp vmem.cpp timer.cpp driver.cpp
    ./misc/depend/Arm/CortexM4/src/: machM4.s Thread.c machM4.c
    ./misc/context/inc/: mutex.cpp
  group application
    ./device/src/: startup_app.cpp
    ./entry/src/: render_app.cpp main_app.cpp explorer_app.cpp info_app.cpp file_app.cpp exec_app.cpp execute.cpp exec_interface.cpp touch_app.cpp battery.cpp settings_app.cpp snake_app.cpp analog_app.cpp analog_app_inv.cpp clock.cpp
    ./analog/src/: adc_core.cpp
  group audio
    ./device/src/: wave.cpp wave_sample.cpp
  group camera
    ./device/src/: camera.cpp
    ./adv7180/src/: ADV7180.cpp
    ./entry/src/: cam_app.cpp
  group tcp_app
    ./tcp_app/src/: mchdrv.c
    ./entry/src/: tcp_app.cpp
  group lwip1.4
    ./lwip-1.4.1/src/core/: def.c dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timers.c udp.c
    ./lwip-1.4.1/src/netif/: etharp.c ethernetif.c slipif.c
    ./lwip-1.4.1/src/core/ipv4/: icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
  group enc28j60
    ./lwip-enc28j60-master/enc28j60driver/: enc28j60.c
software components: CMSIS:CORE 5.0.0, Device:Startup 2.6.0
